IMAGE_BOOT_FILES:append = " imx95-19x19-evk-os08a20-hsb.dtb"
