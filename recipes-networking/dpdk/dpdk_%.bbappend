#Fetch from NXP GitHub
SRC_URI = "git://github.com/NXP/dpdk.git;protocol=https;nobranch=1"
# Use Tag: 'hsb-ear-0.1' that resolves to followng SHA
SRCREV = "d693b57117d421eb643c455c0e55661a122eac8b"

